# Keil uVision project HardWareCheckUCOS3.08.uvprojx, settings and files
target Release (6140000::V6.14::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Objects
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_LOOPUNROLL,NDEBUG
  c include: ..\..\..\Driver\DriverCore\CMSIS;..\..\..\Driver\DriverCore\Math;..\..\..\Driver\DriverCore\Startup;..\..\..\Driver\DriverCore\StdLib\Inc;..\..\..\Driver\DriverCore\StdLib\Src;..\..\..\Driver\DriverCore\StdLibSupport;..\..\..\Driver\DriverCore\UtilFunc;..\..\..\Driver\DriverMCU;..\..\..\Driver\DriverBoard;..\..\..\Driver\DriverBoard\MPU6050_eMPL;..\..\..\CommonFunc\ADT;..\..\..\CommonFunc\SystemUtil;..\..\..\CommonFunc\SeggerRTT;..\..\..\CommonFunc;..\..\..\CommonService;..\DriverConfig\CoreConfig;..\DriverConfig\BoardConfig;..\DriverConfig\OSConfig;..\DriverConfig\UserConfig;..\TaskMain;..\TaskMain\ServiceSupport\ServiceTask;..\TaskMain\ServiceSupport\ServiceImpl;..\TaskMain\ServiceSupport\ServiceIpc;..\TaskMain\ServiceSupport\ServiceUtil;..\TaskMain\AppSupport\AppTask;..\TaskMain\AppSupport\AppImpl;..\TaskMain\AppSupport\AppIpc;..\TaskMain\AppSupport\AppUtil;..\..\..\UCOS_3.08\uC-CPU\Port;..\..\..\UCOS_3.08\uC-CPU\Source;..\..\..\UCOS_3.08\uC-LIB\Port;..\..\..\UCOS_3.08\uC-LIB\Source;..\..\..\UCOS_3.08\uCOS-III\Port;..\..\..\UCOS_3.08\uCOS-III\Source
  asm include: ..\..\..\Driver\DriverCore\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\Driver\DriverCore\Startup\STM32F407_Full.sct
  group CMSIS
    ../../../Driver/DriverCore/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Math
    ../../../Driver/DriverCore/Math/: arm_cortexM4lf_math.lib
  group Startup
    ../../../Driver/DriverCore/Startup/: startup_stm32f40_41xxx.s
  group StdLibInc
    ../../../Driver/DriverCore/StdLib/Inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group StdLibSrc
    ../../../Driver/DriverCore/StdLib/Src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group StdLibSupport
    ../../../Driver/DriverCore/StdLibSupport/: stm32f4xx.h stm32f4xx_it.h system_stm32f4xx.h
  group UtilFunc
    ../../../Driver/DriverCore/UtilFunc/: CoreDelay.h CoreDelayUcos.c CoreInc.h CoreUtil.c CoreUtil.h
  group DriverMCU
    ../../../Driver/DriverMCU/: MCU_ADC.c MCU_ADC.h MCU_Can.c MCU_Can.h MCU_Common.h MCU_DAC.c MCU_DAC.h MCU_IIC.c MCU_IIC.h MCU_Inc.h MCU_Port.c MCU_Port.h MCU_Random.c MCU_Random.h MCU_RTC.c MCU_RTC.h MCU_SDIO.c MCU_SDIO.h MCU_SPI.h MCU_SPI1.c MCU_SPI2.c MCU_Uart.h MCU_Uart1.c MCU_EXTI.c MCU_EXTI.h MCU_IWDG.c MCU_IWDG.h MCU_WWDG.c MCU_WWDG.h MCU_Flash.c MCU_Flash.h MCU_Uart2.c MCU_Uart3.c
  group DriverBoard
    ../../../Driver/DriverBoard/: BoardAT24CXX.c BoardAT24CXX.h BoardBeep.c BoardBeep.h BoardDS18B20.c BoardDS18B20.h BoardInc.h BoardInfraredComm.c BoardInfraredComm.h BoardInOut.c BoardInOut.h BoardKey.c BoardKey.h BoardLed.c BoardLed.h BoardLightSensor.c BoardLightSensor.h BoardMPU6050.c BoardMPU6050.h BoardRS232.c BoardRS232.h BoardRS485.c BoardRS485.h BoardSD.c BoardSD.h BoardSRAM.c BoardSRAM.h BoardMPU6050Base.h BoardW25QXX.c BoardW25QXX.h BoardW25QXXBase.h
  group DriverBoard/MPU6050_eMPL
    ../../../Driver/DriverBoard/MPU6050_eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group CommonFunc/SeggerRTT
    ../../../CommonFunc/SeggerRTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group CommonFunc/ADT
    ../../../CommonFunc/ADT/: ADT_CircleByteQueue.c ADT_CircleByteQueue.h ADT_Inc.h
  group CommonFunc/SystemUtil
    ../../../CommonFunc/SystemUtil/: bget.c bget.h UserMemManage.c UserMemManage.h
  group UCOS/uC-CPU/Port
    ../../../UCOS_3.08/uC-CPU/Port/: cpu.h cpu_a.asm cpu_c.c bsp_user.c bsp_user.h
  group UCOS/uC-CPU/Source
    ../../../UCOS_3.08/uC-CPU/Source/: cpu_core.c cpu_core.h cpu_def.h
  group UCOS/uC-LIB/Source
    ../../../UCOS_3.08/uC-LIB/Source/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS/uCOS-III/Port
    ../../../UCOS_3.08/uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_cpu_isr.asm
  group UCOS/uCOS-III/Source
    ../../../UCOS_3.08/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group CoreConfig
    ../DriverConfig/CoreConfig/: CoreNVIC_Prio.h stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
  group OSConfig
    ../DriverConfig/OSConfig/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UserConfig
    ../DriverConfig/UserConfig/: UserMemManageConfig.h
  group TaskMain
    ../TaskMain/: SystemMain.c SystemTaskConfig.h SystemTaskStart.c
  group ServiceTask
    ../TaskMain/ServiceSupport/ServiceTask/: ServiceTaskConfig.h ServiceTaskHeart.c
  group ServiceImpl
    ../TaskMain/ServiceSupport/ServiceImpl/: ServiceImplHeart.c ServiceImplHeart.h
  group AppTask
    ../TaskMain/AppSupport/AppTask/: AppTaskConfig.h AppTaskDemo.c
